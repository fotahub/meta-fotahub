SUMMARY = "python3-pydbus version ${PV}"
HOMEPAGE = "https://github.com/LEW21/pydbus"
LICENSE = "LGPLv2.1"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-2.1;md5=1a6d268fd218675ffea8be556788b780"

inherit pypi setuptools3

SRC_URI[md5sum] = "c6abd44862322679bd4e907bebc3e0d0"
SRC_URI[sha256sum] = "4207162eff54223822c185da06c1ba8a34137a9602f3da5a528eedf3f78d0f2c"
