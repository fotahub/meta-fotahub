SUMMARY = "python-stringcase version 1.2.0"
HOMEPAGE = "https://github.com/okunishinishi/python-stringcase"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit pypi setuptools3

SRC_URI[md5sum] = "5cb2a0b28f227f19dc830b66f6e46b52"
SRC_URI[sha256sum] = "48a06980661908efe8d9d34eab2b6c13aefa2163b3ced26972902e3bdfd87008"
