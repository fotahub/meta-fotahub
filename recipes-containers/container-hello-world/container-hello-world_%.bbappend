CONTAINER_STARTUP := "${THISDIR}/files/entry.sh"